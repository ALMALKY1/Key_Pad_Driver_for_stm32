# Keil uVision project ARM.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Common
    ./: STD_TYPES.h BIT_OP.h
  group MCAL
    ./: GPIO_Program.c GPIO_Config.h GPIO_Private.h GPIO_Interface.h
  group HAL
    ./: Key_Pad.c Key_pad.h Key_Pad_Cfg.h
  group APP
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
